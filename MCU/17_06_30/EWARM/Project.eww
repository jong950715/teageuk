<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\17_06_30.ewp</path>
  </project>
  <batchBuild />
</workspace>
